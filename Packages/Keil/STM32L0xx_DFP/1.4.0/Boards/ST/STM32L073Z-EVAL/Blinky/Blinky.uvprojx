# Keil uVision project Blinky.uvprojx, settings and files
target STM32L073 RAM (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L073VZ STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.4.0-RC2
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: VECT_TAB_SRAM
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x2000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target STM32L073 Flash (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L073VZ STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.4.0-RC2
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.2.0, CMSIS:RTOS:Keil RTX 4.79.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.4.0
