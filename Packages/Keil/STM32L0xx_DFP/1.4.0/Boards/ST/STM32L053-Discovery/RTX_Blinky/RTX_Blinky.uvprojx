# Keil uVision project RTX_Blinky.uvprojx, settings and files
target STM32L053 Flash (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.4.0-RC2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ELITTLE
  output: RTX_Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Files
    ./: RTX_Blinky.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.4.0
